inherit externalsrc
EXTERNALSRC = "/home/jourdes/w/src/esme-3S3-workspace"
EXTERNALSRC_BUILD = "/home/jourdes/w/src/esme-3S3-workspace"

# initial_rev .: c5667cf232ae5cfb206b1b803dfaba4386ca5e2d
